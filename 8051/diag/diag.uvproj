# Keil uVision project diag.uvproj, settings and files
target C8051F020 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: diag
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: STARTUP.A51 driver_adc.c func.c inicializar.c main.c primitivas_adc.c
  group Headers
    ./: controlador.h ntcm12.h
