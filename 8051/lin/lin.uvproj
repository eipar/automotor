# Keil uVision project lin.uvproj, settings and files
target C8051F020 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: lin
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: STARTUP.A51 func.c inicializar.c main.c
  group Header
    ./: controlador.h ntcm12.h
